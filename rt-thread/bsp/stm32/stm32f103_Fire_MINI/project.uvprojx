# Keil uVision project project.uvprojx, settings and files
target rt-thread (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: rt-thread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER, RT_USING_ARM_LIBC, STM32F103xE
  c include: .;..\..\..\include;applications;.;board;board\CubeMX_Config\Inc;..\libraries\HAL_Drivers;..\libraries\HAL_Drivers\config;..\..\..\libcpu\arm\common;..\..\..\libcpu\arm\cortex-m3;..\..\..\components\dfs\include;..\..\..\components\dfs\filesystems\devfs;..\..\..\components\dfs\filesystems\elmfat;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\spi;..\..\..\components\drivers\include;..\..\..\components\drivers\spi\sfud\inc;..\..\..\components\drivers\include;..\..\..\components\finsh;..\..\..\components\libc\compilers\armlibc;..\..\..\components\libc\compilers\common;..\libraries\STM32F1xx_HAL\CMSIS\Device\ST\STM32F1xx\Include;..\libraries\STM32F1xx_HAL\STM32F1xx_HAL_Driver\Inc;..\libraries\STM32F1xx_HAL\CMSIS\Include
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  scatter file: .\board\linker_scripts\link.sct
  group Kernel
    ../../../src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c signal.c thread.c timer.c
  group Applications
    applications/: Interface_app.c bitmap_app.c drv_beep.c drv_flash.c drv_fonts.c drv_ili9341_lcd.c drv_key.c drv_led.c drv_mpu6050.c drv_timer.c drv_xpt2049_lcd.c gyroscope_app.c main.c menu_app.c message_app.c palette_app.c rtc_app.c schedule_app.c steering_app.c
    ./applications/: kalman_math.c
  group Drivers
    board/: board.c
    board/CubeMX_Config/Src/: stm32f1xx_hal_msp.c
    ../libraries/STM32F1xx_HAL/CMSIS/Device/ST/STM32F1xx/Source/Templates/arm/: startup_stm32f103xe.s
    ../libraries/HAL_Drivers/: drv_gpio.c drv_usart.c drv_hwtimer.c drv_pwm.c drv_spi.c drv_soft_i2c.c drv_rtc.c drv_common.c
  group cpu
    ../../../libcpu/arm/common/: backtrace.c div0.c showmem.c
    ../../../libcpu/arm/cortex-m3/: cpuport.c context_rvds.S
  group Filesystem
    ../../../components/dfs/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c poll.c select.c
    ../../../components/dfs/filesystems/devfs/: devfs.c
    ../../../components/dfs/filesystems/elmfat/: dfs_elm.c ff.c
    ../../../components/dfs/filesystems/elmfat/option/: ccsbcs.c
  group DeviceDrivers
    ../../../components/drivers/hwtimer/: hwtimer.c
    ../../../components/drivers/i2c/: i2c_core.c i2c_dev.c i2c-bit-ops.c
    ../../../components/drivers/misc/: pin.c rt_drv_pwm.c
    ../../../components/drivers/rtc/: rtc.c
    ../../../components/drivers/serial/: serial.c
    ../../../components/drivers/spi/: spi_core.c spi_dev.c spi_flash_sfud.c
    ../../../components/drivers/spi/sfud/src/: sfud.c sfud_sfdp.c
    ../../../components/drivers/src/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
  group finsh
    ../../../components/finsh/: shell.c cmd.c msh.c msh_file.c
  group libc
    ../../../components/libc/compilers/armlibc/: libc.c mem_std.c stdio.c stubs.c
    ../../../components/libc/compilers/common/: time.c
  group STM32_HAL
    ../libraries/STM32F1xx_HAL/CMSIS/Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
    ../libraries/STM32F1xx_HAL/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_crc.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal.c stm32f1xx_hal_cec.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_usart.c stm32f1xx_hal_i2c.c stm32f1xx_hal_spi.c stm32f1xx_ll_spi.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_rtc.c stm32f1xx_hal_rtc_ex.c
